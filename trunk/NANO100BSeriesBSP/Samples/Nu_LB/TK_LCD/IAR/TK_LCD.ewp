# IAR project TK_LCD.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Nano100 series Nuvoton Nano100 series (Nano100,Nano110,Nano120,Nano130)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __LCDDISPLAY_BTL001_LB_H
  ICCARM.CCIncludePath2: ..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\Libraries\Device\Nuvoton\NANO1xx\Include; ..\..\..\..\Libraries\NANO1xx_Drivers\Include; ..\..\..\..\Libraries\NANO1xx_Libs\libtk\IAR
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TK_LCD.bin
  ILINK.IlinkOutputFile: TK_LCD.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../../../Libraries/Device/Nuvoton/NANO1xx/Source/IAR/: startup_nano1xx.s
  group Common
    ../../COMMON/: nano1xx_retarget.c system_nano1xx.c
  group Libraries
    ../../../../Libraries/NANO1xx_Libs/libtk/IAR/: libtk.a
    ../../../../Libraries/NANO1xx_Drivers/Source/: nano1xx_gpio.c nano1xx_lcd.c nano1xx_pwm.c nano1xx_rtc.c nano1xx_sys.c nano1xx_tk.c nano1xx_uart.c
  group User
    ../: config.c LCD.c nano1xx_isr.c RTC.c TK_LCD_main.c
