# Keil uVision project FATFS_SDCard.uvproj, settings and files
target FATFS_SDCard (ARM-ADS)
  device: (Generic) Nano100 Series Nuvoton
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M0")
  output: FATFS_SDCard
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1
  c include: ..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\Device\Nuvoton\NANO1xx\Include;..\..\..\..\Libraries\NANO1xx_Drivers\Include;..\..\..\..\Libraries\NANO1xx_Libs\SDCardLib;..\FF8\src;..\..\..\..\Libraries\NANO1xx_Libs\spiFlashLib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --map --first='startup_nano1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Libraries/Device/Nuvoton/NANO1xx/Source/ARM/: startup_nano1xx.s
  group Libraries
    ../../../../Libraries/NANO1xx_Libs/SDCARDLIB/: SDCard.c
    ../../../../Libraries/NANO1xx_Drivers/Source/: nano1xx_sys.c nano1xx_spi.c
    ../../../../Libraries/NANO1xx_Libs/spiFlashLib/: spiFlash.c
  group Common
    ../../COMMON/: nano1xx_retarget.c system_nano1xx.c
  group User
    ../FF8/src/: diskio.c ff.c
    ../FF8/src/option/: ccsbcs.c
    ../: FATFS_SDCard.c
