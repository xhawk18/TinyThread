<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\FATFS_SDCard.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build FMC Sample Code</name>
      <member>
        <project>FMC</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


