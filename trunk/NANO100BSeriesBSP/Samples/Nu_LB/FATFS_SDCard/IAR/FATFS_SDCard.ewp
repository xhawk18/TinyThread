# IAR project FATFS_SDCard.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Nano100 series Nuvoton Nano100 series (Nano100,Nano110,Nano120,Nano130)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\Libraries\Device\Nuvoton\NANO1xx\Include; ..\..\..\..\Libraries\NANO1xx_Drivers\Include; ..\..\..\..\Libraries\NANO1xx_Libs\SDCARDLIB; ..\ff8\src; ..\..\..\..\Libraries\NANO1xx_Libs\spiFlashLib
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: FATFS_SDCard.bin
  ILINK.IlinkOutputFile: FATFS_SDCard.out
  ILINK.IlinkIcfFile: FATFS_SDCard.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 1
  group CMSIS
    ../../../../Libraries/Device/Nuvoton/NANO1xx/Source/IAR/: startup_nano1xx.s
  group Common
    ../../COMMON/: nano1xx_retarget.c system_nano1xx.c
  group Libraries
    ../../../../Libraries/NANO1xx_Drivers/Source/: nano1xx_spi.c nano1xx_sys.c
    ../../../../Libraries/NANO1xx_Libs/SDCARDLIB/: SDCard.c
    ../../../../Libraries/NANO1xx_Libs/spiFlashLib/: spiFlash.c
  group User
    ../FF8/src/option/: ccsbcs.c
    ../FF8/src/: diskio.c ff.c
    ../: FATFS_SDCard.c
