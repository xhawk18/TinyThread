# IAR project SAMPLE_LD.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Nano100 series Nuvoton Nano100 series (Nano100,Nano110,Nano120,Nano130)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: LDROM=1
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\Libraries\Device\Nuvoton\NANO1xx\Include; ..\..\..\..\Libraries\NANO1xx_Drivers\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SAMPLE_LD.bin
  ILINK.IlinkOutputFile: SAMPLE_LD.out
  ILINK.IlinkIcfFile: NANO1xx.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkOutputFile: Sample_LD.out
  group CMSIS
    ../../../../Libraries/Device/Nuvoton/NANO1xx/Source/IAR/: startup_nano1xx.s
  group Common
    ../../COMMON/: nano1xx_retarget.c system_nano1xx.c
  group Libraries
    ../../../../Libraries/NANO1xx_Drivers/Source/: nano1xx_fmc.c
  group User
    ../: sample_ld.c
