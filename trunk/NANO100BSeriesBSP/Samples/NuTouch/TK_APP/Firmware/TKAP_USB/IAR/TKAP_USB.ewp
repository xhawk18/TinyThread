# IAR project TKAP_USB.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Nano100 series Nuvoton Nano100 series (Nano100,Nano110,Nano120,Nano130)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\..\Libraries\Device\Nuvoton\NANO1xx\Include; ..\..\..\..\..\..\Libraries\NANO1xx_Drivers\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: TKAP_USB.bin
  ILINK.IlinkOutputFile: TKAP_USB.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 1
  group CMSIS
    ../../../../../../Libraries/Device/Nuvoton/NANO1xx/Source/IAR/: startup_nano1xx.s
  group Common
    ../../../../COMMON/: nano1xx_retarget.c system_nano1xx.c
  group Libraries
    ../../../../../../Libraries/NANO1xx_Drivers/Source/: nano1xx_sys.c nano1xx_tk.c nano1xx_usb.c
  group User
    ../: HID_Class.c HIDTransfer_Main.c nano1xx_isr.c nano1xx_tk2usb.c
