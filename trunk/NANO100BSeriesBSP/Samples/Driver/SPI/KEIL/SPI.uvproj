# Keil uVision project SPI.uvproj, settings and files
target SPI (ARM-ADS)
  device: (Generic) Nano100 Series Nuvoton
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M0")
  output: SPI
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\@L.txt"
  c flags: Optim=3 OneElfS=1
  c include: ..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\Device\Nuvoton\NANO1xx\Include;..\..\..\..\Libraries\NANO1xx_Drivers\Include;..\..\..\..\Libraries\NANO1xx_Libs\spiFlashLib
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --map --first='startup_nano1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Libraries/Device/Nuvoton/NANO1xx/Source/ARM/: startup_nano1xx.s
  group Libraries
    ../../../../Libraries/NANO1xx_Drivers/Source/: nano1xx_pdma.c nano1xx_spi.c nano1xx_sys.c
    ../../../../Libraries/NANO1xx_Libs/spiFlashLib/: spiFlash.c
  group Common
    ../../COMMON/: nano1xx_retarget.c system_nano1xx.c
  group User
    ../: main.c nano1xx_isr.c
