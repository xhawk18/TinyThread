# IAR project Condition2.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: M051 series Nuvoton M051 series (M052,M054,M058,M0516)
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\..\M051SeriesBSP\CMSIS\CM0\CoreSupport; ..\..\..\M051SeriesBSP\CMSIS\CM0\DeviceSupport\Nuvoton\M051Series; ..\..\..\M051SeriesBSP\NuvotonPlatform_IAR\Include; ..\..\..\M051SeriesBSP\NuvotonPlatform_IAR\Include\Driver
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: Condition2.srec
  ILINK.IlinkOutputFile: Condition2.out
  ILINK.IlinkIcfFile: M051.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ./: Main.c tt_config.h
  group CMSIS
    ../../../M051SeriesBSP/CMSIS/CM0/CoreSupport/: core_cm0.c core_cm0.h
    ../../../M051SeriesBSP/CMSIS/CM0/DeviceSupport/Nuvoton/M051Series/: M051Series.h system_M051Series.c system_M051Series.h
    ../../../M051SeriesBSP/CMSIS/CM0/DeviceSupport/Nuvoton/M051Series/startup/iar/: startup_M051Series.s
  group Driver
    ../../../M051SeriesBSP/NuvotonPlatform_IAR/Src/Driver/: DrvGPIO.c DrvSYS.c DrvUART.c retarget.c
  group TinyThread
    ../../../Src/: tt_condition.c tt_msg.c tt_mutex.c tt_recursive_mutex.c tt_semaphore.c tt_sys.c tt_sys_iar.s tt_thread.c tt_time.c
