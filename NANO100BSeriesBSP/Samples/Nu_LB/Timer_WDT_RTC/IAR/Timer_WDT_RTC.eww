<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Timer_WDT_RTC.ewp</path>
  </project>
  <batchBuild/>
</workspace>


