# IAR project Timer_WDT_RTC.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Nano100 series Nuvoton Nano100 series (Nano100,Nano110,Nano120,Nano130)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\Libraries\Device\Nuvoton\NANO1xx\Include; ..\..\..\..\Libraries\NANO1xx_Drivers\Include; ..\..\COMMON
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Timer_WDT_RTC.bin
  ILINK.IlinkOutputFile: Timer_WDT_RTC.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../../../Libraries/Device/Nuvoton/NANO1xx/Source/IAR/: startup_nano1xx.s
  group Common
    ../../COMMON/: EBI_LCM_config.c EBI_LCM_OTM3225A.c nano1xx_retarget.c system_nano1xx.c
  group Libraries
    ../../../../Libraries/NANO1xx_Drivers/Source/: nano1xx_ebi.c nano1xx_sys.c
  group User
    ../: nano1xx_isr.c Timer_WDT_RTC.c
