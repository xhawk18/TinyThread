# Keil uVision project ReadSim_CCID.uvproj, settings and files
target ReadSim_CCID (ARM-ADS)
  device: (Generic) Nano100 Series Nuvoton
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M0")
  output: ReadSim_CCID
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1
  c include: ..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\Device\Nuvoton\NANO1xx\Include;..\..\..\..\Libraries\NANO1xx_Drivers\Include;..\..\COMMON
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --map --first='startup_nano1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Libraries/Device/Nuvoton/NANO1xx/Source/ARM/: startup_nano1xx.s
  group Libraries
    ../../../../Libraries/NANO1xx_Drivers/Source/: nano1xx_smartcard.c nano1xx_usb.c nano1xx_ebi.c nano1xx_gpio.c nano1xx_sys.c
    ../../../../Libraries/NANO1xx_Libs/SmartCardLib/KEIL/: SmartCardLib.lib
  group Common
    ../../COMMON/: EBI_LCM_config.c EBI_LCM_OTM3225A.c nano1xx_retarget.c system_nano1xx.c
  group User
    ../: CCID_Class.c Ccid_if.c Ifd_protocol.c nano1xx_isr.c ReadSim_CCID.c
