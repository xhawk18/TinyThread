# Keil uVision project TK_LCD.uvproj, settings and files
target TK_LCD (ARM-ADS)
  device: (Generic) Nano100 Series Nuvoton
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M0")
  output: TK_LCD +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1
  c define: __LCDDISPLAY_BTL001_LB_H
  c misc: --c99
  c include: ..\..\..\..\Libraries\Device\Nuvoton\NANO1xx;..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\NANO1xx_Drivers\Include;..\..\..\..\Libraries\NANO1xx_Libs\libtk;..\..\..\..\Libraries\Device\Nuvoton\NANO1xx\Include;..\..\..\..\Libraries\NANO1xx_Libs\libtk\KEIL
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --map --first='startup_nano1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Libraries/Device/Nuvoton/NANO1xx/Source/ARM/: startup_nano1xx.s
  group Libraries
    ../../../../Libraries/NANO1xx_Drivers/Source/: nano1xx_gpio.c nano1xx_lcd.c nano1xx_rtc.c nano1xx_sys.c nano1xx_tk.c nano1xx_uart.c nano1xx_pwm.c
    ../../../../Libraries/NANO1xx_Libs/libtk/KEIL/: libtk.lib
  group Common
    ../../COMMON/: nano1xx_retarget.c system_nano1xx.c
  group User
    ../: config.c nano1xx_isr.c LCD.c RTC.c TK_LCD_main.c
