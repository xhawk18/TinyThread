# Keil uVision project LCD_TK.uvproj, settings and files
target LCD_TK (ARM-ADS)
  device: (Generic) Nano100 Series Nuvoton
  cpu: CLOCK(32000000) CPUTYPE("Cortex-M0")
  output: LCD_TK
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: __LCDDISPLAY_BTL001_H
  c misc: --c99
  c include: ..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\Libraries\Device\Nuvoton\NANO1xx\Include;..\..\..\..\Libraries\NANO1xx_Drivers\Include;..\..\..\..\Libraries\NANO1xx_Libs\libtk\KEIL
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --map --first='startup_nano1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Libraries/Device/Nuvoton/NANO1xx/Source/ARM/: startup_nano1xx.s
  group Libraries
    ../../../../Libraries/NANO1xx_Libs/libtk/KEIL/: libtk.lib
    ../../../../Libraries/NANO1xx_Drivers/Source/: nano1xx_lcd.c nano1xx_sys.c nano1xx_tk.c nano1xx_timer.c
  group Common
    ../../COMMON/: nano1xx_retarget.c system_nano1xx.c Smpl_LCD.c
  group User
    ../: config.c main.c nano1xx_isr.c
