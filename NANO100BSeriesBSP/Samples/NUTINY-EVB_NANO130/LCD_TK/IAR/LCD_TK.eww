<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\LCD_TK.ewp</path>
  </project>
  <batchBuild/>
</workspace>


