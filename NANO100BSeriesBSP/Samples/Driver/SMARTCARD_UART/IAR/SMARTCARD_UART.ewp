# IAR project SMARTCARD_UART.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Nano100 series Nuvoton Nano100 series (Nano100,Nano110,Nano120,Nano130)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_ASSERT
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\Libraries\Device\Nuvoton\NANO1xx\Include; ..\..\..\..\Libraries\NANO1xx_Drivers\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: SMARTCARD_UART.bin
  ILINK.IlinkOutputFile: SMARTCARD_UART.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 1
  group CMSIS
    ../../../../Libraries/Device/Nuvoton/NANO1xx/Source/IAR/: startup_nano1xx.s
  group Common
    ../../COMMON/: nano1xx_retarget.c system_nano1xx.c
  group Libraries
    ../../../../Libraries/NANO1xx_Drivers/Source/: nano1xx_smartcard.c
    ../../../../Libraries/NANO1xx_Libs/SmartCardLib/IAR/: SmartCardLib.a
  group User
    ../: main.c nano1xx_isr.c
