# IAR project Tk_Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Nano100 series Nuvoton Nano100 series (Nano100,Nano110,Nano120,Nano130)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\Libraries\Device\Nuvoton\NANO1xx\Include; ..\..\..\..\Libraries\NANO1xx_Drivers\Include; ..\..\..\..\Libraries\NANO1xx_Libs\libtk\IAR
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Tk_Demo.bin
  ILINK.IlinkOutputFile: Tk_Demo.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../../../Libraries/Device/Nuvoton/NANO1xx/Source/IAR/: startup_nano1xx.s
  group Common
    ../../COMMON/: nano1xx_retarget.c system_nano1xx.c
  group Libraries
    ../../../../Libraries/NANO1xx_Libs/libtk/IAR/: libtk.a
    ../../../../Libraries/NANO1xx_Drivers/Source/: nano1xx_tk.c
  group User
    ../: config.c main.c nano1xx_isr.c
