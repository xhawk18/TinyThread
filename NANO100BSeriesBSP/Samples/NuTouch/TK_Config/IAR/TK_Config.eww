<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Tk_config.ewp</path>
  </project>
  <batchBuild/>
</workspace>


