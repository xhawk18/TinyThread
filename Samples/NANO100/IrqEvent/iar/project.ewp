# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: Nano100 series Nuvoton Nano100 series (Nano100,Nano110,Nano120,Nano130)
  ICCARM.CCDefines: DEBUG_ENABLE_SEMIHOST
  ICCARM.CCIncludePath2: ..; ..\..\..\..\NANO100BSeriesBSP\Libraries\CMSIS\Include; ..\..\..\..\NANO100BSeriesBSP\Libraries\Device\Nuvoton\NANO1xx\Include; ..\..\..\..\NANO100BSeriesBSP\Libraries\NANO1xx_Drivers\Include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: DEBUG_ENABLE_SEMIHOST
  OBJCOPY.OOCOutputFile: project.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ../: Main.c tt_config.h
  group CMSIS
    ../../../../NANO100BSeriesBSP/Libraries/Device/Nuvoton/NANO1xx/Source/IAR/: startup_nano1xx.s
  group Driver
    ../../../../NANO100BSeriesBSP/Samples/Driver/COMMON/: nano1xx_retarget.c system_nano1xx.c
    ../../../../NANO100BSeriesBSP/Libraries/NANO1xx_Drivers/Source/: nano1xx_timer.c
  group TinyThread
    ../../../../Src/: tt.c
