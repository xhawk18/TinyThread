# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: NUC100 series Nuvoton NUC100 series (NUC100,NUC101,NUC102,NUC120,NUC122,NUC130,NUC140)
  ICCARM.CCDefines: DEBUG_ENABLE_SEMIHOST
  ICCARM.CCIncludePath2: ..; ..\..\..\..\NUC100SeriesBSP\CMSIS\CM0\CoreSupport; ..\..\..\..\NUC100SeriesBSP\CMSIS\CM0\DeviceSupport\Nuvoton\NUC1xx; ..\..\..\..\NUC100SeriesBSP\NuvotonPlatform_IAR\Include; ..\..\..\..\NUC100SeriesBSP\NuvotonPlatform_IAR\Include\Driver
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: DEBUG_ENABLE_SEMIHOST
  OBJCOPY.OOCOutputFile: project.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ../: Main.c tt_config.h
  group CMSIS
    ../../../../NUC100SeriesBSP/CMSIS/CM0/CoreSupport/: core_cm0.c core_cm0.h
    ../../../../NUC100SeriesBSP/CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/: NUC1xx.h system_NUC1xx.c system_NUC1xx.h
    ../../../../NUC100SeriesBSP/CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/startup/iar/: startup_NUC1xx.s
  group Driver
    ../../../../NUC100SeriesBSP/NuvotonPlatform_IAR/Src/Driver/: DrvGPIO.c DrvSYS.c DrvUART.c retarget.c
  group TinyThread
    ../../../../Src/: tt.c
