# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: M051 series Nuvoton M051 series (M052,M054,M058,M0516)
  ICCARM.CCDefines: DEBUG_ENABLE_SEMIHOST
  ICCARM.CCIncludePath2: ..; ..\..\..\..\M051SeriesBSP\LibM051Series\CMSIS\CM0\CoreSupport; ..\..\..\..\M051SeriesBSP\LibM051Series\CMSIS\CM0\DeviceSupport\Nuvoton\M051Series; ..\..\..\..\M051SeriesBSP\LibM051Series\StdDriver\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  AARM.ADefines: DEBUG_ENABLE_SEMIHOST
  OBJCOPY.OOCOutputFile: project.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ../: Main.c tt_config.h
  group CMSIS
    ../../../../M051SeriesBSP/LibM051Series/CMSIS/CM0/CoreSupport/: core_cm0.c core_cm0.h
    ../../../../M051SeriesBSP/LibM051Series/CMSIS/CM0/DeviceSupport/Nuvoton/M051Series/: M051Series.h system_M051Series.c system_M051Series.h
    ../../../../M051SeriesBSP/LibM051Series/CMSIS/CM0/DeviceSupport/Nuvoton/M051Series/startup/iar/: startup_M051Series.s
  group Driver
    ../../../../M051SeriesBSP/LibM051Series/StdDriver/src/: retarget.c
  group TinyThread
    ../../../../Src/: tt.c
